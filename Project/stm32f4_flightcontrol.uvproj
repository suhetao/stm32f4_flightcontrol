# Keil uVision project stm32f4_flightcontrol.uvproj, settings and files
target stm32f4_flightcontrol (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4_flightcontrol
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o .\stm32f4_flightcontrol\stm32f4_flightcontrol.bin .\stm32f4_flightcontrol\stm32f4_flightcontrol.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F40_41xxx ARM_MATH_CM4 __FPU_PRESENT MPU9250
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\inc;..\Application\inc;..\Libraries\eMPL;..\Matrix\inc;..\Algorithm\inc;..\Math\inc;..\miniIMU;..\miniIMU\FP;..\miniAHRS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Application/Src/: main.c system_stm32f4xx.c
    ../Application/src/: stm32f4_delay.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Algorithm
    ../Algorithm/src/: Quaternion.c Control.c PID.c INS_EKF.c
  group Matrix
    ../Matrix/src/: Matrix.c AdditionalMatrix.c
  group DSP_Lib
    ../Libraries/CMSIS/DSP_Lib/Lib/: arm_cortexM4lf_math.lib
  group Math
    ../Math/src/: FastMath.c Vector.c Rotation.c
